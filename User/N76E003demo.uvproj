# Keil uVision project N76E003demo.uvproj, settings and files
target N76E003 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: N76E003demo +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\Common;..\Core;..\User;..\HardWare
  group User
    ./: STARTUP.A51 main.c includes.h
  group HardWare
    ../HardWare/: EEPROM.c
  group Common
    ../Common/: Common.c Delay.c
  group Document
    ../: ReadMe.txt
